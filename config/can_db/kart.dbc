VERSION "1.0"

NS_ :
    NS_DESC_
    CM_
    BA_
    VAL_

BO_ 1 ECU_HEARTBEAT: 8 ECU
 SG_ 1 : HEARTBEAT m4
 SG_ 2 : FAULT_STATE m4
 SG_ 3 : STATE m4

BO_ 2 BMS_PACK: 8 BMS
 SG_ 1 : PACK_VOLTAGE_V F32
 SG_ 2 : PACK_CURRENT_A F32
 SG_ 3 : STATE_OF_CHARGE F32

BO_ 3 BMS_FAULT: 8 BMS
 SG_ 1 : BMS_FAULT_STATE m4
 SG_ 2 : CURRENT_LIMIT_A F32
 SG_ 3 : CONTACTOR_PERMISSION m4

BO_ 4 MOTOR_STATUS: 8 MOTOR
 SG_ 1 : RPM F32
 SG_ 2 : PHASE_CURRENT_A F32
 SG_ 3 : TEMPERATURE_C F32

VAL_ 1 "OFF" 0;
VAL_ 1 "INIT" 1;
VAL_ 1 "READY" 2;
VAL_ 1 "DRIVE" 3;
VAL_ 1 "FAULT" 4;
